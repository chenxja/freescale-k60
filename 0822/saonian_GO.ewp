# IAR project saonian_GO.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_DMAov7620.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: saonian_GO.srec
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  group Project_Settings/link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Sources
    src/: LQ12864.c LQ12864.h
  group Sources/C
    src/Sources/C/: isr.c
    src/: main.c
  group Sources/C/Component_C
    src/Sources/C/Component_C/: gpio.c light.c uart.c wdog.c
  group Sources/C/Frame_C
    src/Sources/C/Frame_C/: common.c sysinit.c vectors.c
  group Sources/H
    src/Sources/H/: includes.h
  group Sources/H/Component_H
    src/Sources/H/Component_H/: gpio.h IR.h light.h uart.h wdog.h
    src/: keyboard.h keyboard_PD.h lptmr.h
  group Sources/H/Frame_H
    src/Sources/H/Frame_H/: common.h MK60N512VMD100.h sysinit.h vectors.h
